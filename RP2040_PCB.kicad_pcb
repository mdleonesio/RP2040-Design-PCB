# Repository mdleonesio/RP2040-Design-PCB

## KiCad design RP2040_PCB.kicad_pcb

Parts:
C1, C2: 15p; C_0402_1005Metric
C3, C4: 10u; C_0805_2012Metric
C5, C6, C7, C9, C11, C12, C13, C14, C15, C16: 100n; C_0402_1005Metric
C8, C10: 1u; C_0402_1005Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J2: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal_modified
R1, R3: 1k; R_0402_1005Metric
R2, R6: 4.7; R_0402_1005Metric
R4, R5: 27; R_0402_1005Metric
SW2: UBUT; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U3: RP2040; RP2040-QFN-56
U4: SHT31-DIS; Sensirion_DFN-8-1EP_2.5x2.5mm_P0.5mm_EP1.1x1.7mm
Y1: ABM8-272-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C4.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, R1.1, U1.2 (VO), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.35 (GPIO23), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.5 (VDD)
/GPIO0: R6.1, U3.2 (GPIO0)
/GPIO1: R2.1, U3.3 (GPIO1)
/RUN: U3.26 (RUN)
/USB_D+: J2.3 (D+), R4.1
/USB_D-: J2.2 (D-), R5.1
/XIN: C1.1, U3.20 (XIN), Y1.1
/XOUT: R3.1, U3.21 (XOUT)
/~USB_BOOT: R1.2, SW2.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J2.5 (GND), J2.6 (Shield), SW2.1, U1.1 (GND), U3.19 (TESTEN), U3.57 (GND), U4.2 (ADDR), U4.7 (R), U4.8 (VSS), U4.9 (VSS), Y1.2, Y1.4
unnamed: C2.1, R3.2, Y1.3
unnamed: R5.2, U3.46 (USB_DM)
unnamed: R4.2, U3.47 (USB_DP)
unnamed: R6.2, U4.4 (SCL)
unnamed: R2.2, U4.1 (SDA)
VBUS: C3.1, J2.1 (VBUS), U1.3 (VI)

Board: 2 copper layers, 50.0 x 50.0 mm, 32 parts (0 on the bottom side), 16 nets.

## Commit log

2024-09-18 Create gerbers
